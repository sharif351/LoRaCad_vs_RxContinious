# Keil uVision project lora_sx126x.uvprojx, settings and files
target lora_sx126x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lora_sx126x +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L073xx USE_MODEM_LORA
  c include: ..\..\..\src;..\..\..\src\boards;..\..\..\src\boards\NucleoL073;..\..\..\src\boards\NucleoL073\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\inc;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\radio\sx126x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group apps
    ../../../src/apps/lora_sx126x/: main.c
  group boards\NucleoL073
    ../../../src/boards/NucleoL073/: board.c delay-board.c gpio-board.c rtc-board.c spi-board.c uart-board.c sx1262dvk1cas-board.c
  group boards\NucleoL073\cmsis
    ../../../src/boards/NucleoL073/cmsis/arm-std/: startup_stm32l073xx.s
    ../../../src/boards/NucleoL073/cmsis/: system_stm32l0xx.c
  group boards\NucleoL073\STM32L0xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c
    ../../../src/boards/mcu/: utilities.c
  group radio
    ../../../src/radio/sx126x/: sx126x.c
  group system
    ../../../src/system/: delay.c fifo.c gpio.c timer.c uart.c
